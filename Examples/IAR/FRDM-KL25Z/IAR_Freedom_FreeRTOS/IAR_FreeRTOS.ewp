# IAR project IAR_FreeRTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: C:\Freescale\PExDrv v10.4\eclipse\ProcessorExpert\lib\Kinetis\iofiles\; C:\Freescale\PExDrv v10.4\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\; Sources; Generated_Code
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAR_FreeRTOS.srec
  ILINK.IlinkOutputFile: IAR_FreeRTOS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: C:\Freescale\PExDrv v10.0\eclipse\ProcessorExpert\lib\Kinetis\iofiles\; C:\Freescale\PExDrv v10.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\; C:\tmp\wsp_DriverSuite\IAR_Freedom_FreeRTOS\Sources\; C:\tmp\wsp_DriverSuite\IAR_Freedom_FreeRTOS\Generated_Code\; C:\ProgramData\Processor Expert\CWMCU_PE5_00\Examples\FRDM-KL25Z\IAR_Freedom_FreeRTOS\Sources\; C:\ProgramData\Processor Expert\CWMCU_PE5_00\Examples\FRDM-KL25Z\IAR_Freedom_FreeRTOS\Generated_Code\; C:\Freescale\PExDrv v10.2\eclipse\ProcessorExpert\lib\Kinetis\iofiles\; C:\Freescale\PExDrv v10.2\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\
  ICCARM.CCOptLevel: 3
  group Freescale Processor Expert/GeneratedASMs
    Generated_Code/: HF1_HardFaultHandler.s portasm.s WAIT1_Wait100Cycles.s
  group Freescale Processor Expert/GeneratedCs
    Generated_Code/: BitIoLdd1.c Cpu.c croutine.c FRTOS1.c heap_1.c heap_2.c heap_3.c heap_4.c HF1.c LED1.c LEDpin1.c list.c PE_LDD.c port.c queue.c tasks.c timers.c UTIL1.c Vectors.c WAIT1.c
    Sources/: Events.c ProcessorExpert.c
  group Freescale Processor Expert/GeneratedHs
    Generated_Code/: BitIoLdd1.h Cpu.h croutine.h FreeRTOS.h FreeRTOSConfig.h FRTOS1.h HF1.h IO_Map.h LED1.h LEDpin1.h list.h mpu_wrappers.h PE_Const.h PE_Error.h PE_LDD.h PE_Types.h portable.h portmacro.h portTicks.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h UTIL1.h WAIT1.h
    Sources/: Events.h

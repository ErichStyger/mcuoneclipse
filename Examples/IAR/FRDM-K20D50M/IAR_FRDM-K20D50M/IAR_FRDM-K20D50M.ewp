# IAR project IAR_FRDM-K20D50M.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX128xxx5 Freescale MK20DX128xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: C:\Freescale\PExDrv v10.2\eclipse\ProcessorExpert\lib\Kinetis\iofiles\; C:\Freescale\PExDrv v10.2\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\; C:\Users\tastyger\Data\CW\Prj\wsp_DriverSuite\IAR_FRDM-K20D50M\Sources\; C:\Users\tastyger\Data\CW\Prj\wsp_DriverSuite\IAR_FRDM-K20D50M\Generated_Code\; C:\ProgramData\Processor Expert\CWMCU_PE5_00\Examples\FRDM-K20D50M\IAR_FRDM-K20D50M\Sources\; C:\ProgramData\Processor Expert\CWMCU_PE5_00\Examples\FRDM-K20D50M\IAR_FRDM-K20D50M\Generated_Code\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: IAR_FRDM-K20D50M.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: ProjectInfo.xml
  group Freescale Processor Expert/GeneratedASMs
    Generated_Code/: portasm.s
  group Freescale Processor Expert/GeneratedCs
    Generated_Code/: BitIoLdd1.c BitIoLdd2.c BitIoLdd3.c Cpu.c croutine.c FRTOS1.c heap_1.c heap_2.c heap_3.c heap_4.c LEDB.c LEDG.c LEDpin1.c LEDpin2.c LEDpin3.c LEDR.c list.c PE_LDD.c port.c queue.c tasks.c timers.c UTIL1.c Vectors.c
    Sources/: Events.c ProcessorExpert.c
  group Freescale Processor Expert/GeneratedHs
    Generated_Code/: BitIoLdd1.h BitIoLdd2.h BitIoLdd3.h Cpu.h croutine.h FreeRTOS.h FreeRTOSConfig.h FRTOS1.h IO_Map.h LEDB.h LEDG.h LEDpin1.h LEDpin2.h LEDpin3.h LEDR.h list.h mpu_wrappers.h PE_Const.h PE_Error.h PE_LDD.h PE_Types.h portable.h portmacro.h portTicks.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h UTIL1.h
    Sources/: Events.h

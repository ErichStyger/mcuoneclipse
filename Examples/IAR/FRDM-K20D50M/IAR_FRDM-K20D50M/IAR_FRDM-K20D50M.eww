<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IAR_FRDM-K20D50M.ewp</path>
  </project>
  <batchBuild/>
</workspace>



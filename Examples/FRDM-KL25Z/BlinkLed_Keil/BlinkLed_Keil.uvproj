# Keil uVision project BlinkLed_Keil.uvproj, settings and files
target MKL25Z128xxx4 (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: BlinkLed_Keil
  c flags: Optim=1
  c include: "C:\Freescale\PExDrv v10.2\eclipse\ProcessorExpert\lib\Kinetis\iofiles";"C:\Freescale\PExDrv v10.2\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc";".\Sources";".\Generated_Code";".\Generated_Code";".\Sources";".\Project_Settings\Startup_Code"
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  scatter file: .\Project_Settings\Linker_Files\ProcessorExpert.scf
  group GeneratedASMs
    ./Generated_Code/: portasm.s
  group GeneratedCs
    ./Generated_Code/: BitIoLdd1.c Cpu.c FRTOS1.c HF1.c LED1.c LEDpin1.c PE_LDD.c UTIL1.c Vectors.c WAIT1.c croutine.c list.c port.c queue.c tasks.c timers.c heap_1.c heap_2.c heap_3.c heap_4.c CS1.c EVNT1.c
    ./Sources/: Events.c ProcessorExpert.c
    ./Project_Settings/Startup_Code/: startup_ARM_CC.c
  group GeneratedHs
    ./Generated_Code/: BitIoLdd1.h Cpu.h FRTOS1.h FreeRTOS.h FreeRTOSConfig.h HF1.h IO_Map.h LED1.h LEDpin1.h PE_Const.h PE_Error.h PE_LDD.h PE_Types.h StackMacros.h UTIL1.h WAIT1.h croutine.h list.h mpu_wrappers.h portTicks.h portable.h portmacro.h projdefs.h queue.h semphr.h task.h timers.h CS1.h EVNT1.h
    ./Sources/: Events.h

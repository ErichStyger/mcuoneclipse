# Keil uVision project BlinkLed_Keil.uvprojx, settings and files
target MKL25Z128xxx4 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.13.0
  cpu: IRAM(0x1FFFF000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BlinkLed_Keil
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: "C:\nxp\PExDrv v10.4\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc";"C:\nxp\PExDrv v10.4\eclipse\ProcessorExpert\lib\Kinetis\iofiles";".\Sources";".\Generated_Code";".\Generated_Code";".\Project_Settings\Startup_Code";".\Sources"
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: .\Project_Settings\Linker_Files\ProcessorExpert.scf
  group GeneratedASMs
    ./Generated_Code/: portasm.s
  group GeneratedCs
    ./Generated_Code/: BitIoLdd1.c Cpu.c FRTOS1.c HF1.c LED1.c LEDpin1.c PE_LDD.c UTIL1.c Vectors.c WAIT1.c croutine.c list.c port.c queue.c tasks.c timers.c heap_1.c heap_2.c heap_3.c heap_4.c CS1.c EVNT1.c event_groups.c MCUC1.c heap_5.c KIN1.c mpu_wrappers.c
    ./Sources/: Events.c ProcessorExpert.c
    ./Project_Settings/Startup_Code/: startup_ARM_CC.c
  group GeneratedHs
    ./Generated_Code/: BitIoLdd1.h Cpu.h FRTOS1.h FreeRTOS.h FreeRTOSConfig.h HF1.h IO_Map.h LED1.h LEDpin1.h PE_Const.h PE_Error.h PE_LDD.h PE_Types.h StackMacros.h UTIL1.h WAIT1.h croutine.h list.h mpu_wrappers.h portTicks.h portable.h portmacro.h projdefs.h queue.h semphr.h task.h timers.h CS1.h EVNT1.h event_groups.h CS1config.h EVNT1config.h FRTOS1config.h HF1config.h LED1config.h MCUC1.h MCUC1config.h UTIL1config.h WAIT1config.h deprecated_definitions.h freertos_tasks_c_additions.h KIN1.h KIN1config.h mpu_prototypes.h
    ./Sources/: Events.h
    C:/Freescale/Kepler/eclipse/ProcessorExpert/lib/Kinetis/pdd/inc/: ADC_PDD.h CMP_PDD.h COP_PDD.h DAC_PDD.h DMAMUX_PDD.h DMA_PDD.h FTFA_PDD.h GPIO_PDD.h I2C_PDD.h LPTMR_PDD.h MCM_PDD.h PDD_Types.h PIT_PDD.h PORT_PDD.h RTC_PDD.h SIM_PDD.h SPI_PDD.h SysTick_PDD.h TPM_PDD.h UART0_PDD.h UART_PDD.h USB_PDD.h
    C:/Freescale/Kepler/eclipse/ProcessorExpert/lib/Kinetis/iofiles/: MKL25Z4.h
    ./RTE/: RTE_Components.h
software components: CMSIS:CORE 5.0.0

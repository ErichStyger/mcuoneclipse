# Keil uVision project FRDM-K64F_BlinkLed_Keil.uvprojx, settings and files
target MK64FN1M0xxx12 (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  pack: Keil.Kinetis_K60_DFP.1.2.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FRDM-K64F_BlinkLed_Keil
  c flags: Optim=1 wLevel=2
  c include: "C:\Freescale\PExDrv v10.4\eclipse\ProcessorExpert\lib\Kinetis\pdd2\MK64FN1M0LQ12\system";"C:\Freescale\PExDrv v10.4\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc";"C:\Freescale\PExDrv v10.4\eclipse\ProcessorExpert\lib\Kinetis\iofiles";"C:\Freescale\PExDrv v10.4\eclipse\ProcessorExpert\lib\Kinetis\pdd2\MK64FN1M0LQ12\peripherals";".\Sources";".\Generated_Code";".\Generated_Code";".\Project_Settings\Startup_Code";".\Sources";"C:\Freescale\PExDrv v10.4\eclipse\ProcessorExpert\lib\Kinetis\pdd2\MK64FN1M0LQ12\peripherals";"C:\Freescale\PExDrv v10.4\eclipse\ProcessorExpert\lib\Kinetis\pdd2\MK64FN1M0LQ12\system"
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\Project_Settings\Linker_Files\ProcessorExpert.scf
  group GeneratedASMs
    ./Generated_Code/: portasm.s
  group GeneratedCs
    C:/Freescale/PExDrv v10.4/eclipse/ProcessorExpert/lib/Kinetis/pdd2/MK64FN1M0LQ12/peripherals/: ADC0_Init.c ADC1_Init.c AIPS0_Init.c AIPS1_Init.c AXBS_Init.c CAN0_Init.c CMP0_Init.c CMP1_Init.c CMP2_Init.c CMT_Init.c CRC_Init.c DAC0_Init.c DAC1_Init.c DMAMUX_Init.c DMA_Init.c ENET_Init.c EWM_Init.c FB_Init.c FMC_Init.c FTFE_Init.c FTM0_Init.c FTM1_Init.c FTM2_Init.c FTM3_Init.c I2C0_Init.c I2C1_Init.c I2C2_Init.c I2S0_Init.c LLWU_Init.c LPTMR0_Init.c MCM_Init.c MPU_Init.c NVIC_Init.c PDB0_Init.c PIT_Init.c PMC_Init.c PORTA_Init.c PORTB_Init.c PORTC_Init.c PORTD_Init.c PORTE_Init.c PTA_Init.c PTB_Init.c PTC_Init.c PTD_Init.c PTE_Init.c RCM_Init.c RNG_Init.c RTC_Init.c SDHC_Init.c SIM_Init.c SMC_Init.c SPI0_Init.c SPI1_Init.c SPI2_Init.c SysTick_Init.c SystemControl_Init.c UART0_Init.c UART1_Init.c UART2_Init.c UART3_Init.c UART4_Init.c UART5_Init.c USB0_Init.c USBDCD_Init.c VREF_Init.c WDOG_Init.c
    ./Generated_Code/: BitIoLdd1.c CS1.c Cpu.c FRTOS1.c LED1.c LEDpin1.c PE_LDD.c Pins1.c UTIL1.c WAIT1.c croutine.c event_groups.c heap_1.c heap_2.c heap_3.c heap_4.c list.c port.c queue.c tasks.c timers.c
    C:/Freescale/PExDrv v10.4/eclipse/ProcessorExpert/lib/Kinetis/pdd2/MK64FN1M0LQ12/system/: CPU_Init.c Peripherals_Init.c Vectors.c
    ./Sources/: Events.c main.c
    ./Project_Settings/Startup_Code/: startup_ARM_CC.c
  group GeneratedHs
    C:/Freescale/PExDrv v10.4/eclipse/ProcessorExpert/lib/Kinetis/pdd2/MK64FN1M0LQ12/peripherals/: ADC0_Init.h ADC1_Init.h AIPS0_Init.h AIPS1_Init.h AXBS_Init.h CAN0_Init.h CMP0_Init.h CMP1_Init.h CMP2_Init.h CMT_Init.h CRC_Init.h DAC0_Init.h DAC1_Init.h DMAMUX_Init.h DMA_Init.h ENET_Init.h EWM_Init.h FB_Init.h FMC_Init.h FTFE_Init.h FTM0_Init.h FTM1_Init.h FTM2_Init.h FTM3_Init.h I2C0_Init.h I2C1_Init.h I2C2_Init.h I2S0_Init.h LLWU_Init.h LPTMR0_Init.h MCM_Init.h MPU_Init.h NVIC_Init.h PDB0_Init.h PIT_Init.h PMC_Init.h PORTA_Init.h PORTB_Init.h PORTC_Init.h PORTD_Init.h PORTE_Init.h PTA_Init.h PTB_Init.h PTC_Init.h PTD_Init.h PTE_Init.h RCM_Init.h RNG_Init.h RTC_Init.h SDHC_Init.h SIM_Init.h SMC_Init.h SPI0_Init.h SPI1_Init.h SPI2_Init.h SysTick_Init.h SystemControl_Init.h UART0_Init.h UART1_Init.h UART2_Init.h UART3_Init.h UART4_Init.h UART5_Init.h USB0_Init.h USBDCD_Init.h VREF_Init.h WDOG_Init.h
    C:/Freescale/PExDrv v10.4/eclipse/ProcessorExpert/lib/Kinetis/pdd/inc/: ADC_PDD.h CAN_PDD.h CMP_PDD.h CMT_PDD.h CRC_PDD.h DAC_PDD.h DMAMUX_PDD.h DMA_PDD.h ENET_PDD.h EWM_PDD.h FMC_PDD.h FTFE_PDD.h FTM_PDD.h GPIO_PDD.h I2C_PDD.h LLWU_PDD.h LPTMR_PDD.h MCM_PDD.h PDB_PDD.h PDD_Types.h PIT_PDD.h PMC_PDD.h PORT_PDD.h RCM_PDD.h RNGA_PDD.h RTC_PDD.h SAI_PDD.h SCB_PDD.h SDHC_PDD.h SIM_PDD.h SMC_PDD.h SPI_PDD.h SysTick_PDD.h UART_PDD.h USBDCD_PDD.h USB_PDD.h VREF_PDD.h WDOG_PDD.h
    ./Generated_Code/: BitIoLdd1.h CPU_Config.h CS1.h Cpu.h FRTOS1.h FreeRTOS.h FreeRTOSConfig.h IO_Map.h Init_Config.h LED1.h LEDpin1.h PE_Const.h PE_Error.h PE_LDD.h PE_Types.h Pins1.h StackMacros.h UTIL1.h Vectors_Config.h WAIT1.h croutine.h event_groups.h list.h mpu_wrappers.h portTicks.h portable.h portmacro.h projdefs.h queue.h semphr.h task.h timers.h
    C:/Freescale/PExDrv v10.4/eclipse/ProcessorExpert/lib/Kinetis/pdd2/MK64FN1M0LQ12/system/: CPU_Init.h PDD_Includes.h Peripherals_Init.h
    ./Sources/: Events.h
    C:/Freescale/PExDrv v10.4/eclipse/ProcessorExpert/lib/Kinetis/iofiles/: MK64F12.h

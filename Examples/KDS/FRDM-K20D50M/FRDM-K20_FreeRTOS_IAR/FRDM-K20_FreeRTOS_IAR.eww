<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FRDM-K20_FreeRTOS_IAR.ewp</path>
  </project>
  <batchBuild/>
</workspace>



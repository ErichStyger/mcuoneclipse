# IAR project FRDM-KL25Z_FreeRTOS_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\; C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\iofiles\; C:\tmp\wsp_kds\FRDM-KL25Z_FreeRTOS_IAR\Sources\; C:\tmp\wsp_kds\FRDM-KL25Z_FreeRTOS_IAR\Generated_Code\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: FRDM-KL25Z_FreeRTOS_IAR.srec
  ILINK.IlinkOutputFile: FRDM-KL25Z_FreeRTOS_IAR.out
  ILINK.IlinkIcfFile: C:\tmp\wsp_kds\FRDM-KL25Z_FreeRTOS_IAR\Project_Settings\Linker_Files\ProcessorExpert.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: ProjectInfo.xml
  group Freescale Processor Expert/GeneratedASMs
    Generated_Code/: portasm.s
  group Freescale Processor Expert/GeneratedCs
    Generated_Code/: BitIoLdd1.c BitIoLdd2.c BitIoLdd3.c Cpu.c croutine.c event_groups.c FRTOS1.c heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c LEDB.c LEDG.c LEDpin1.c LEDpin2.c LEDpin3.c LEDR.c list.c PE_LDD.c port.c queue.c tasks.c timers.c UTIL1.c Vectors.c
    Sources/: Events.c main.c
  group Freescale Processor Expert/GeneratedHs
    ../../../Freescale/KDS_2.0.0/eclipse/ProcessorExpert/lib/Kinetis/pdd/inc/: ADC_PDD.h CMP_PDD.h COP_PDD.h DAC_PDD.h DMA_PDD.h DMAMUX_PDD.h FTFA_PDD.h GPIO_PDD.h I2C_PDD.h LPTMR_PDD.h MCM_PDD.h PDD_Types.h PIT_PDD.h PORT_PDD.h RTC_PDD.h SIM_PDD.h SPI_PDD.h SysTick_PDD.h TPM_PDD.h UART0_PDD.h UART_PDD.h USB_PDD.h
    Generated_Code/: BitIoLdd1.h BitIoLdd2.h BitIoLdd3.h Cpu.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h FRTOS1.h IO_Map.h LEDB.h LEDG.h LEDpin1.h LEDpin2.h LEDpin3.h LEDR.h list.h mpu_wrappers.h PE_Const.h PE_Error.h PE_LDD.h PE_Types.h portable.h portmacro.h portTicks.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h UTIL1.h
    Sources/: Events.h
    ../../../Freescale/KDS_2.0.0/eclipse/ProcessorExpert/lib/Kinetis/iofiles/: MKL25Z4.h

<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Freescale Processor Expert</name>
    <group>
      <name>GeneratedASMs</name>
      <file>
        <name>$PROJ_DIR$\Generated_Code\portasm.s</name>
      </file>
    </group>
    <group>
      <name>GeneratedCs</name>
      <file>
        <name>$PROJ_DIR$\Generated_Code\BitIoLdd1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\BitIoLdd2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\BitIoLdd3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\Cpu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\croutine.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\event_groups.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Sources\Events.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\FRTOS1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\heap_1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\heap_2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\heap_3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\heap_4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\heap_5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\LEDB.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\LEDG.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\LEDpin1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\LEDpin2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\LEDpin3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\LEDR.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\list.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Sources\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\PE_LDD.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\port.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\queue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\tasks.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\timers.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\UTIL1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\Vectors.c</name>
      </file>
    </group>
    <group>
      <name>GeneratedHs</name>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\ADC_PDD.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\BitIoLdd1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\BitIoLdd2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\BitIoLdd3.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\CMP_PDD.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\COP_PDD.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\Cpu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\croutine.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\DAC_PDD.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\deprecated_definitions.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\DMA_PDD.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\DMAMUX_PDD.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\event_groups.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Sources\Events.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\FreeRTOS.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\FreeRTOSConfig.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\FRTOS1.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\FTFA_PDD.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\GPIO_PDD.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\I2C_PDD.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\IO_Map.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\LEDB.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\LEDG.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\LEDpin1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\LEDpin2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\LEDpin3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\LEDR.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\list.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\LPTMR_PDD.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\MCM_PDD.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\iofiles\MKL25Z4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\mpu_wrappers.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\PDD_Types.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\PE_Const.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\PE_Error.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\PE_LDD.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\PE_Types.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\PIT_PDD.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\PORT_PDD.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\portable.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\portmacro.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\portTicks.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\projdefs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\queue.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\RTC_PDD.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\semphr.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\SIM_PDD.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\SPI_PDD.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\StackMacros.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\SysTick_PDD.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\task.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\timers.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\TPM_PDD.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\UART0_PDD.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\UART_PDD.h</name>
      </file>
      <file>
        <name>C:\Freescale\KDS_2.0.0\eclipse\ProcessorExpert\lib\Kinetis\pdd\inc\USB_PDD.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Generated_Code\UTIL1.h</name>
      </file>
    </group>
  </group>
  <file>
    <name>$PROJ_DIR$\ProjectInfo.xml</name>
  </file>
</project>



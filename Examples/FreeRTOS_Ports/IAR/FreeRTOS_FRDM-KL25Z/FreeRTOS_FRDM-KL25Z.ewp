# IAR project FreeRTOS_FRDM-KL25Z.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MKL25Z128VLK4; DEBUG; FREEDOM
  ICCARM.CCIncludePath2: Sources; Sources\FreeRTOS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: Sources; Sources\FreeRTOS
  OBJCOPY.OOCOutputFile: FreeRTOS_FRDM-KL25Z.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Sources\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group (top)
    ./: readme.txt
  group Sources
    Sources/: main.c startup_MKL25Z4.s
  group Sources/FreeRTOS
    Sources/FreeRTOS/: croutine.c croutine.h FreeRTOS.h FreeRTOSConfig.h heap_1.c heap_2.c heap_3.c heap_4.c license.txt list.c list.h mpu_wrappers.h port.c portable.h portasm.s portmacro.h portTicks.h projdefs.h queue.c queue.h semphr.h StackMacros.h task.h tasks.c timers.c timers.h
